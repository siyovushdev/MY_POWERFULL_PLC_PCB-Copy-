File: .history/DI_FAST_GROUP.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: 112
Other:
- removed sheet DI_Fast_Module2
- removed sheet DI_Fast_Module7
